# Keil uVision project Project.uvprojx, settings and files
target GD32427V_START (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F427ZG GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.1.0
  cpu: IRAM(0x20000000,0x030000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x0100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: GD32F427
  c include: ..\CMSIS;..\Hardware;..\Library\Include;..\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ../CMSIS/: system_gd32f4xx.c
  group Startup
    ../Startup/: startup_gd32f407_427.s
  group Doc
    ../User/: readme.txt
  group Library
    ../Library/Source/: gd32f4xx_rcu.c gd32f4xx_gpio.c gd32f4xx_pmu.c gd32f4xx_tim.c misc.c gd32f4xx_usart.c gd32f4xx_adc.c gd32f4xx_dac.c gd32f4xx_i2c.c gd32f4xx_spi.c gd32f4xx_dma.c gd32f4xx_rtc.c gd32f4xx_flash.c gd32f4xx_exti.c
  group User
    ../Library/Source/: gd32f4xx_dcmi.c
    ../User/: gd32f4xx_it.c main.c systick.c delay.h delay.c program.h program.c
  group Hardware
    ../Hardware/: led.c timer.c usart.c dac.h dac.c dcmi.c ov2640.c sccb.c malloc.c myiic.c mpu6050.c iic.c icm42670.c icm42670.h adc.c adc.h hm609a.c gdflash.c gdflash.h rtc.c rtc.h mos_sw.h mos_sw.c network.h
